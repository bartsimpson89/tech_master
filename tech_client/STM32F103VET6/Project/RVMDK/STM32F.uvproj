# Keil uVision project STM32F.uvproj, settings and files
target STM32F_RAM (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F_RAM
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\..\STM32F10x_StdPeriph_Driver\inc;..\..\CMSIS\Core\CM3;..\..\User
  memory RVCT4: ROM 0x20000000 size 0xf000
  memory RVCT9: RAM 0x2000f000 size 0x1000
  group User
    ../../User/: main.c stm32f10x_it.c user_led.c user_uart.c user_protocol.c user_flash.c user_global.c user_msgheap.c user_display.c user_init.c
  group StdPeriph_Driver
    ../../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CM3
    ../../CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group StartUp
    ../../CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
target STM32F_FLASH (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: STM32F_FLASH +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
